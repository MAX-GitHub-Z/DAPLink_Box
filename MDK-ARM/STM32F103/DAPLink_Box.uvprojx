# Keil uVision project DAPLink_Box.uvprojx, settings and files
target DAPLink_Box (6190000::V6.19::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DAPLink_Box +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xE,STM32F1
  c include: ..\..\APP\Main\Inc;..\..\APP\USB_DEVICE\App;..\..\APP\USB_DEVICE\Target;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\APP\DAP;..\..\TinyUSB\scr;..\..\TinyUSB\bsp;..\..\TinyUSB\STM32_USB_Device_Library\Core\Inc;..\..\CMSIS-DAP\Include;..\..\nr_micro_shell\inc;..\..\APP\nr_shell;..\..\fatfs;..\..\APP\SD_FATFS;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\GCC\ARM_CM3;..\..\TinyUSB\scr\osal;..\..\FlashAlgo\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --info=summarysizes --info=unused --info=totals
  group Application/MDK-ARM
    ../../APP/SD_FATFS/: bsp_eval_sd.c
    ./: startup_stm32f103xe.s
  group Application/main
    ../../APP/Main/Src/: gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c usb.c board.c family.c usb_descriptors.c usart.c msc_disk.c stm32f1xx_hal_timebase_tim.c cpu_usage.c DAP_diskio.c
    ../../APP/DAP/: DAP_gpio.c
    ../../APP/nr_shell/: nr_micro_shell_port.c
  group Drivers/CMSIS
    ../../APP/Main/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group CMSIS-DAP
    ../../CMSIS-DAP/Source/: DAP.c JTAG_DP.c SW_DP.c SWO.c DAP_vendor.c UART.c SWD_flash.c SWD_host.c SWD_opt.c
  group TinyUsb
    ../../TinyUSB/scr/class/cdc/: cdc_device.c
    ../../TinyUSB/scr/class/msc/: msc_device.c
    ../../TinyUSB/scr/class/hid/: hid_device.c
    ../../TinyUSB/scr/common/: tusb_fifo.c
    ../../TinyUSB/scr/device/: usbd.c usbd_control.c
    ../../TinyUSB/scr/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c
    ../../TinyUSB/scr/: tusb.c
  group nr_micro_shell
    ../../nr_micro_shell/src/: nr_micro_shell_cmds.c nr_micro_shell_core.c
  group FATFS
    ../../fatfs/: diskio.c ff.c ffsystem.c ffunicode.c fatfs_test.c
  group FreeRTOS
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
